Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler für Kühldecken, Aufputz, 24 VAC/VDC, 2-/4-Rohr, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: DA420600, Raumtemperaturregler für Kühldecken, Aufputz, 24 VAC/VDC, 2-/4-Rohr
In: Raum
Description: Elektronischer Aufputz-Klimaregler zur Heiz-/Kühlregelung in 2- und 4-Rohr-Leitungssysteme für Hotel-, Wohn- und Geschäftsräume. Bis zu 5 Ventilantriebe (24V~, stromlos geschlossen oder stromlos offen) können je Ausgang angesteuert werden. Besonders geeignet zur Kühldeckenregelung durch die Möglichkeit der Taupunktüberwachung über optionale externe Taupunktsensoren. Um die Trägheit von Regelstrecken mit Kühldecken zu kompensieren, verfügt das Gerät über einen Temperaturfühlereingang zur Aufschaltung eines externen Strahlungsfühlers (optional). Als Behördenvariante, bei der der Regler für Unbefugte unerreichbar sein soll, kann der externe Fühler auch als Raumfühler (optional) ausgeführt werden. Mit einem internem Poti kann die Verwendung des internen, des externen oder die Verwendung beider Fühler mit einer einstellbaren Wichtung gewählt werden. Kontakteingänge für ECO-Funktion und AUS (Frostschutz).; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: DA420600; ModelLabel: KTRRB-052.244; GlobalTradeItemNumber: 4050528028112; ProductURL: https://alre.de/produkt_DA420600
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.095
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 78.3; Höhe: 83.4; Tiefe: 25.5; RAL-Nummer: 9010; Anschluss: sonstige; Art der Spannungsversorgung: 24 V AC; Kontaktausführung: Schließer (NO); Messbereich: 13; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: I; Max. Spannung der Kontakte: 24; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 1; Differenzwert: 1; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-DA420600.pdf
